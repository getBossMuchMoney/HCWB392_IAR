# IAR project HCWB392.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __DEBUG; HC32F460; USE_DEVICE_DRIVER_LIB
  ICCARM.CCIncludePath2: ..\..\..\..\CMSIS\common; ..\..\..\..\app\app\BeaconTx; ..\..\..\..\app\BleAppProfile; ..\..\..\..\app\ble\Include; ..\..\..\..\app\ble\Service\BAS; ..\..\..\..\app\ble\Service\BleServiceBase; ..\..\..\..\app\ble\Service\DIS; ..\..\..\..\app\ble\Service\GAP; ..\..\..\..\app\ble\Service\GATT; ..\..\..\..\app\ble\Service\HID_KB_MS_CS; ..\..\..\..\driver\inc; ..\..\..\..\app\ble\Include; ..\..\..\..\app\ble\Service\UDF01S
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HCWB392.hex
  ILINK.IlinkOutputFile: HCWB392.out
  ILINK.IlinkIcfFile: ..\..\..\..\CMSIS\EWARM\config\HC32F460xE.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\app\ble\Lib\ble.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../../../../app/BleAppProfile/: ble_profile_app.c ble_profile_def.c
    ../../../../app/app/BeaconTx/: BleAppSetting.h main.c user.c
  group CMSIS
    ../../: startup_hc32f460.s
    ../../../../CMSIS/common/: system_hc32f460.c
  group Driver
    ../../../../driver/src/: hc32f460_clk.c hc32f460_efm.c hc32f460_exint_nmi_swi.c hc32f460_gpio.c hc32f460_icg.c hc32f460_interrupts.c hc32f460_pwc.c hc32f460_sram.c hc32f460_timer0.c hc32f460_utility.c
  group Service
    ../../../../app/ble/Service/BAS/: ble_service_bas.c
    ../../../../app/ble/Service/BleServiceBase/: ble_service_base.c
    ../../../../app/ble/Service/DIS/: ble_service_dis.c
    ../../../../app/ble/Service/GAP/: ble_service_gap.c
    ../../../../app/ble/Service/GATT/: ble_service_gatt.c
    ../../../../app/ble/Service/HID_KB_MS_CS/: ble_service_hid_kb_ms_cs.c
    ../../../../app/ble/Service/UDF01S/: ble_service_udf01s.c
