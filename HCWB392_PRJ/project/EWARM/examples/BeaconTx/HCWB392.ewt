<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\app\BleAppProfile\ble_profile_app.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\app\BleAppProfile\ble_profile_def.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\app\app\BeaconTx\BleAppSetting.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\app\app\BeaconTx\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\app\app\BeaconTx\user.c</name>
    </file>
  </group>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\..\startup_hc32f460.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\CMSIS\common\system_hc32f460.c</name>
    </file>
  </group>
  <group>
    <name>Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\driver\src\hc32f460_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\driver\src\hc32f460_efm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\driver\src\hc32f460_exint_nmi_swi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\driver\src\hc32f460_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\driver\src\hc32f460_icg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\driver\src\hc32f460_interrupts.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\driver\src\hc32f460_pwc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\driver\src\hc32f460_sram.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\driver\src\hc32f460_timer0.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\driver\src\hc32f460_utility.c</name>
    </file>
  </group>
  <group>
    <name>Service</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\app\ble\Service\BAS\ble_service_bas.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\app\ble\Service\BleServiceBase\ble_service_base.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\app\ble\Service\DIS\ble_service_dis.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\app\ble\Service\GAP\ble_service_gap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\app\ble\Service\GATT\ble_service_gatt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\app\ble\Service\HID_KB_MS_CS\ble_service_hid_kb_ms_cs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\app\ble\Service\UDF01S\ble_service_udf01s.c</name>
    </file>
  </group>
</project>


